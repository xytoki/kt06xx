# Keil uVision project SH88F4051.uvproj, settings and files
target VX (MCS-51)
  device: SH88F4051A Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16600000)
  output: SH88F4051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: VX
  c include: .\h
  group Source Group 1
    ./c/: I2C.c KT_WirelessMicTxdrv.c LCD_KEY.c main.c
